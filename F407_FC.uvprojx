# Keil uVision project F407_FC.uvprojx, settings and files
target Anopilot (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F407_FC +hex
  AfterMake: fromelf --bin !L --output TEST.ANO
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c misc: --c99
  c include: .\applications;.\build;.\drivers;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\ST\STM32F4xx\Include;.\Libraries\USBStack\INC;.\Libraries\FatFS\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applications
    ./applications/: include.h stm32f4xx_conf.h main.c stm32f4xx_it.c scheduler.c scheduler.h init.c init.h parameter.c parameter.h ctrl.c ctrl.h imu.c imu.h mymath.c mymath.h rc.c data_transfer.c data_transfer.h rc.h version.c filter.c filter.h height_ctrl.h myctrl.c height_ctrl.c myctrl.h
  group Drivers
    ./drivers/: time.c time.h pwm_in.c pwm_in.h pwm_out.c pwm_out.h i2c_soft.c i2c_soft.h mpu6050.c mpu6050.h ak8975.c ak8975.h led.c led.h usart.c usart.h ultrasonic.c ultrasonic.h
  group Libraries
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Note
    ./doc/: note.txt record.txt
software components: CMSIS:CORE 4.1.0
